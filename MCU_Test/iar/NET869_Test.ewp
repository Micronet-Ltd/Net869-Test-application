# IAR project NET869_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256xxx10 Freescale MK20DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1; CPU_MK20DX256VMC10=1; FSL_RTOS_MQX=1; TWR_K60D100M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../MQX_OS/rtos/mqx/config/mcu/MK20D10; ../../MQX_OS/rtos/mqx/config/board/net869/; ..\..\MQX_OS\rtos\mqx\config\board\net869; ..\..\MQX_OS\rtos\mqx\config\mcu\MK20D10; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\include; ..\..\MQX_OS\BSP\rtos\mqx\mqx_stdlib\source\include; ../../MQX_OS/BSP/rtos/mqx/config/common; ../../MQX_OS/BSP/rtos/mqx/mqx/source/bsp; ../../MQX_OS/BSP/rtos/mqx/mqx/source/include; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\cpu; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\core\M4; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_serial; ..\..\MQX_OS\BSP\rtos\mqx\mqx_stdlib\source\stdio; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_tty; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_dummy; ../../MQX_OS/BSP/platform/drivers/inc; ../../MQX_OS/BSP/platform/drivers/src/uart; ../../MQX_OS/BSP/platform/drivers/src/gpio; ../../MQX_OS/BSP/platform/drivers/src/pit; ../../MQX_OS/BSP/platform/drivers/src/edma; ../../MQX_OS/BSP/platform/system/inc; ../../MQX_OS/BSP/platform/osa/inc; ../../MQX_OS/BSP/rtos; ../../MQX_OS/BSP/platform/utilities/inc; ../../MQX_OS/BSP/platform/CMSIS/Include; ../../MQX_OS/BSP/platform/devices; ../../MQX_OS/BSP/platform/devices/MK20D10/include; ../../MQX_OS/BSP/platform/devices/MK20D10/startup; ..\..\MQX_OS\BSP\platform\CMSIS\Include; ..\..\MQX_OS\usb\usb_core\device\include\net869; ..\..\MQX_OS\usb\usb_core\device\sources\bsp\net869; ../../MQX_OS/BSP/usb/adapter/sources; ../../MQX_OS/BSP/usb/adapter/sources/sdk; ../../MQX_OS/BSP/usb/usb_core/device/include/MK60D10; ../../MQX_OS/BSP/usb/usb_core/device/include; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/audio; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/cdc; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/common; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/composite; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/hid; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/include; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/include/config; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/msd; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/phdc; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/video; ../../MQX_OS/BSP/usb/usb_core/device/sources/controller/khci; ../../MQX_OS/BSP/usb/usb_core/device/sources/controller; ../../MQX_OS/BSP/usb/usb_core/hal; ../../MQX_OS/BSP/usb/usb_core/include; ../..; ../../MQX_OS/BSP/platform/system/inc; ../../MQX_OS/BSP/platform/hal/inc; ../../MQX_OS/BSP/platform/drivers/inc; ../../MQX_OS/BSP/platform/drivers/src/mpu; ../../MQX_OS/BSP/platform/startup; ..\Sources\FPGA_API; ..\Sources\J1708; ..\Sources; ..\Board_Files; ..\Sources\I2C
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; CPU_MK20DX256VLQ10=1
  AARM.AUserIncludes: ..\..\MQX_OS\BSP\platform\devices\MK20D10\startup\iar; ..\..\MQX_OS\BSP\platform\devices
  OBJCOPY.OOCOutputFile: NET869_Test.srec
  ILINK.IlinkOutputFile: NET869_Test.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x4000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: ../../MQX_OS/BSP/platform/devices/MK20D10/linker/iar/MK20DX256xxx10_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\MQX_OS\MQX_USB_DEVICE\iar\Debug_IAR\libusbd_mqx.a; ..\..\MQX_OS\MQX_PSP\iar\Debug_IAR\lib_mqx.a; ..\..\MQX_OS\MQX_LIB\iar\Debug_IAR\libksdk_mqx_lib.a; ..\..\MQX_OS\MQX_STDLIB\iar\Debug_IAR\lib_mqx_stdlib.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK20DX256VMC10; FSL_RTOS_MQX; TWR_K60D100M; TOWER
  ICCARM.CCIncludePath2: ../../MQX_OS/rtos/mqx/config/mcu/MK20D10; ../../MQX_OS/rtos/mqx/config/board/net869/; ..\..\MQX_OS\rtos\mqx\config\board\net869; ..\..\MQX_OS\rtos\mqx\config\mcu\MK20D10; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\include; ..\..\MQX_OS\BSP\rtos\mqx\mqx_stdlib\source\include; ../../MQX_OS/BSP/rtos/mqx/config/common; ../../MQX_OS/BSP/rtos/mqx/mqx/source/bsp; ../../MQX_OS/BSP/rtos/mqx/mqx/source/include; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\cpu; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\core\M4; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m\compiler\iar; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\psp\cortex_m; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_serial; ..\..\MQX_OS\BSP\rtos\mqx\mqx_stdlib\source\stdio; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_tty; ..\..\MQX_OS\BSP\rtos\mqx\mqx\source\nio\drivers\nio_dummy; ../../MQX_OS/BSP/platform/drivers/inc; ../../MQX_OS/BSP/platform/drivers/src/uart; ../../MQX_OS/BSP/platform/drivers/src/gpio; ../../MQX_OS/BSP/platform/drivers/src/pit; ../../MQX_OS/BSP/platform/drivers/src/edma; ../../MQX_OS/BSP/platform/system/inc; ../../MQX_OS/BSP/platform/osa/inc; ../../MQX_OS/BSP/rtos; ../../MQX_OS/BSP/platform/utilities/inc; ../../MQX_OS/BSP/platform/CMSIS/Include; ../../MQX_OS/BSP/platform/devices; ../../MQX_OS/BSP/platform/devices/MK20D10/include; ../../MQX_OS/BSP/platform/devices/MK20D10/startup; ..\..\MQX_OS\BSP\platform\CMSIS\Include; ..\..\MQX_OS\usb\usb_core\device\include\net869; ..\..\MQX_OS\usb\usb_core\device\sources\bsp\net869; ../../MQX_OS/BSP/usb/adapter/sources; ../../MQX_OS/BSP/usb/adapter/sources/sdk; ../../MQX_OS/BSP/usb/usb_core/device/include/MK60D10; ../../MQX_OS/BSP/usb/usb_core/device/include; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/audio; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/cdc; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/common; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/composite; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/hid; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/include; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/include/config; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/msd; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/phdc; ../../MQX_OS/BSP/usb/usb_core/device/sources/classes/video; ../../MQX_OS/BSP/usb/usb_core/device/sources/controller/khci; ../../MQX_OS/BSP/usb/usb_core/device/sources/controller; ../../MQX_OS/BSP/usb/usb_core/hal; ../../MQX_OS/BSP/usb/usb_core/include; ../..; ../../MQX_OS/BSP/platform/system/inc; ../../MQX_OS/BSP/platform/hal/inc; ../../MQX_OS/BSP/platform/drivers/inc; ../../MQX_OS/BSP/platform/drivers/src/mpu; ../../MQX_OS/BSP/platform/startup; ..\Sources\FPGA_API; ..\Sources\J1708; ..\Sources\POWER_MGM; ..\Sources; ..\Board_Files; ..\Sources\I2C
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\..\MQX_OS\MQX_USB_DEVICE\iar\Release_IAR\libusbd_mqx.a; ..\..\MQX_OS\MQX_LIB\iar\Debug_IAR\libksdk_mqx_lib.a; ..\..\MQX_OS\MQX_PSP\iar\Release_IAR\lib_mqx.a; ..\..\MQX_OS\MQX_STDLIB\iar\Release_IAR\lib_mqx_stdlib.a
  group board
    ../Board_Files/: board.c board.h gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h
  group BSP Files
    ../../MQX_OS/BSP/rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c
    ../../MQX_OS/BSP/rtos/mqx/mqx/source/include/: mqx.h
    ../../MQX_OS/rtos/mqx/mqx/source/bsp/: mqx_main.c
  group Config Files
    ../../MQX_OS/rtos/mqx/config/mcu/MK20D10/: mqx_sdk_config.h
    ../../MQX_OS/rtos/mqx/config/board/net869/: user_config.h
  group Config Files/Common
    ../../MQX_OS/BSP/rtos/mqx/config/common/: lite_config.h mqx_cnfg.h small_ram_config.h verif_enabled_config.h
  group sources
    ../Sources/: main_tasks.c tasks_list.c tasks_list.h uart_configuration.c uart_configuration.h
  group sources/Acc
    ../Sources/Acc/: acc_task.c
  group sources/FPGA_API
    ../Sources/FPGA_API/: fpga_API.c fpga_API.h
  group sources/I2C
    ../Sources/I2C/: i2c_configuration.c i2c_configuration.h
  group sources/J1708
    ../Sources/J1708/: J1708_task.c J1708_task.h
  group utilities/Debug_console
    Y:/Aviram/obc_5_mcu/MQX_OS/BSP/platform/utilities/src/: fsl_debug_console.c fsl_misc_utilities.c print_scan.c print_scan.h
    Y:/Aviram/obc_5_mcu/MQX_OS/BSP/platform/utilities/inc/: fsl_debug_console.h fsl_misc_utilities.h
